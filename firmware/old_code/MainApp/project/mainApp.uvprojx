# Keil uVision project mainApp.uvprojx, settings and files
target mainApp (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: mainApp +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM32F1, ENABLE_SERIAL_DEBUG, DEBUG_TIMOTION, DEBUG_HANDSET, DEBUG_RPI, CACH2, USE_TIMOTION_BOX, USE_JIECANG_BOX
  c include: E:\mlabviet\stm\stm32f1\hal\CMSIS\CM3\CoreSupport;E:\mlabviet\stm\stm32f1\hal\CMSIS\CM3\DeviceSupport\ST\STM32F10x;E:\mlabviet\stm\stm32f1\hal\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;E:\mlabviet\stm\stm32f1\hal\STM32F10x_StdPeriph_Driver\inc;..\user;..\..\..\..\..\..\hal_pic_st_ti\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CMIS
    E:/mlabviet/stm/stm32f1/hal/CMSIS/CM3/CoreSupport/: core_cm3.c
    E:/mlabviet/stm/stm32f1/hal/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Drivers
    E:/mlabviet/stm/stm32f1/hal/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c
  group User
    ../user/: stm32f10x_it.c
  group Startup
    E:/mlabviet/stm/stm32f1/hal/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group UserDriver
    ../../../../../../hal_pic_st_ti/src/: MyUart.c MyFlash.c eeprom.c Timer.c AutonomousCommFrame.c DataFrame.c
    ../user/: main.c Speaker.c ButtonLeds.c BoxController.c AddonBoard.c TimHandset.c Debug.c RPI.c JiecangBox.c TimBox.c
software components: CMSIS:CORE 5.0.0, CMSIS:DSP 1.4.6
