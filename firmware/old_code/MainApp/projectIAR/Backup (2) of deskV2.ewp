# IAR project Backup (2) of deskV2.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103RC ST STM32F103RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD; USE_STM32F1; USE_JIECANG_BOX; USE_TIMOTION_BOX; CACH2; USE_IAR; DEBUG_JIECANG
  ICCARM.CCIncludePath2: ..\user; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\iar; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\..\..\..\Linux\myLib\Library\inc; ..\..\..\..\..\..\..\hal_pic_st_ti\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: deskV2.srec
  ILINK.IlinkOutputFile: deskV2.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../user/: main.c
  group Application/AddonBoard
    ../user/: AddonBoard.c
  group Application/AddonBoard/BoxController
    ../user/: BoxController.c
  group Application/AddonBoard/BoxController/Jiecang
    ../user/: JiecangBox.c
  group Application/AddonBoard/BoxController/Timotion
    ../user/: TimBox.c TimHandset.c
  group Application/AddonBoard/DebugModule
    ../user/: Debug.c
  group Application/AddonBoard/MBL_Module
    ../user/: ButtonLeds.c
  group Application/AddonBoard/RPI
    ../user/: RPI.c
  group Application/AddonBoard/SpeakerModule
    ../user/: Speaker.c
  group Application/CommunicationFrame
    ../../../../../../../Linux/myLib/Library/src/Device/: AutonomousCommFrame.c JiecangCommFrame.c TimboxCommFrame.c
  group Application/CustomDrivers
    ../../../../../../../Linux/myLib/Library/src/MicroController/: eeprom.c MyFlash.c MyUart.c Timer.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group hal_driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
    ../user/: stm32f10x_it.c
  group Readme
    ../doc/: readme.txt
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f103xe.s
